# Keil uVision project STM32G4xx.uvprojx, settings and files
target STM32G4xx_32 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: STM32G4xx_32
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=1 uC99=1
  c define: FLASH_MEM STM32G4xx_32
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target STM32G4xx_64 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.7.0
  cpu: as above
  output: STM32G4xx_64
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=1 uC99=1
  c define: FLASH_MEM STM32G4xx_64
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target STM32G4xx_128 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.7.0
  cpu: as above
  output: STM32G4xx_128
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=1 uC99=1
  c define: FLASH_MEM STM32L4x_2048
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
