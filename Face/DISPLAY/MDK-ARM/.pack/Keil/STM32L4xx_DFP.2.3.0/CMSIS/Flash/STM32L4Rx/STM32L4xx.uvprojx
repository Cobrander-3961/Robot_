# Keil uVision project STM32L4xx.uvprojx, settings and files
target STM32L4xx_1024 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: STM32L4Rx_2048
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 uC99=1
  c define: FLASH_MEM, STM32L4x_2048
  c include: ..\
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target STM32L4xx_512 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: STM32L4xx_512
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 uC99=1
  c define: FLASH_MEM, STM32L4x_512
  c include: ..\
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target STM32L4xx_256 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: as above
  output: STM32L4xx_256
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 uC99=1
  c define: FLASH_MEM, STM32L4x_256
  c include: ..\
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target STM32L4xx_2048 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: as above
  output: STM32L4Rx_2048_Dual
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 uC99=1
  c define: FLASH_MEM, STM32L4x_2048
  c include: ..\
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
