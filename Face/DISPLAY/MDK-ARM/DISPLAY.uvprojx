# Keil uVision project DISPLAY.uvprojx, settings and files
target DISPLAY (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L431RBTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00004000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: DISPLAY +hex
  AfterMake: srec_cat.exe @splitHex1.cmd
  AfterMake: srec_cat.exe @splitHex2.cmd
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32L431xx
  c misc: --no-multibyte-chars
  c include: ../Core/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../Drivers/CMSIS/Include;../Drivers/LCD;../Drivers/ST7789;../Drivers/Norflash;../Drivers/NS2009;../middlewares/st/touchgfx/framework/include;../lvgl;../lvgl/Src;../lvgl/port;..\lv\src\generated;..\lv\src\custom;..\lv\src\generated\guider_customer_fonts;..\lv\src\generated\guider_fonts;..\lv\custom;..\lv\generated
  library: MicroLIB
  memory RVCT1: ROM 0x90000000 size 0x800000
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x4000
  scatter file: .\DISPLAY.sct
  group Application/MDK-ARM
    ./: startup_stm32l431xx.s
  group Application/User/Core
    ../Drivers/ST7789/: st7789.c
    ../Drivers/Norflash/: norflash.c qspi.c
    ../Drivers/NS2009/: ns2009.c
    ../Core/Src/: main.c gpio.c crc.c dma.c i2c.c quadspi.c spi.c tim.c usart.c stm32l4xx_it.c stm32l4xx_hal_msp.c stm32l4xx_hal_timebase_tim.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c stm32l4xx_hal_qspi.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l4xx.c
  group LVGL/Port
    ../lvgl/port/: disp.c indev.c
    ../: lv_conf.h
  group LVGL/SRC
    ../lvgl/Src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../lvgl/Src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../lvgl/Src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../lvgl/Src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../lvgl/Src/layouts/flex/: lv_flex.c
    ../lvgl/Src/layouts/grid/: lv_grid.c
    ../lvgl/Src/libs/bmp/: lv_bmp.c
    ../lvgl/Src/libs/ffmpeg/: lv_ffmpeg.c
    ../lvgl/Src/libs/freetype/: lv_freetype.c
    ../lvgl/Src/libs/fsdrv/: lv_fs_cbfs.c lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../lvgl/Src/libs/gif/: gifdec.c lv_gif.c
    ../lvgl/Src/libs/png/: lodepng.c lv_png.c
    ../lvgl/Src/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../lvgl/Src/libs/rlottie/: lv_rlottie.c
    ../lvgl/Src/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../lvgl/Src/libs/tiny_ttf/: lv_tiny_ttf.c
    ../lvgl/Src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_malloc_builtin.c lv_math.c lv_mem.c lv_memcpy_builtin.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../lvgl/Src/others/file_explorer/: lv_file_explorer.c
    ../lvgl/Src/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../lvgl/Src/others/gridnav/: lv_gridnav.c
    ../lvgl/Src/others/ime/: lv_ime_pinyin.c
    ../lvgl/Src/others/imgfont/: lv_imgfont.c
    ../lvgl/Src/others/monkey/: lv_monkey.c
    ../lvgl/Src/others/msg/: lv_msg.c
    ../lvgl/Src/others/snapshot/: lv_snapshot.c
    ../lvgl/Src/themes/basic/: lv_theme_basic.c
    ../lvgl/Src/themes/default/: lv_theme_default.c
    ../lvgl/Src/themes/mono/: lv_theme_mono.c
    ../lvgl/Src/widgets/animimg/: lv_animimg.c
    ../lvgl/Src/widgets/arc/: lv_arc.c
    ../lvgl/Src/widgets/bar/: lv_bar.c
    ../lvgl/Src/widgets/btn/: lv_btn.c
    ../lvgl/Src/widgets/btnmatrix/: lv_btnmatrix.c
    ../lvgl/Src/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../lvgl/Src/widgets/canvas/: lv_canvas.c
    ../lvgl/Src/widgets/chart/: lv_chart.c
    ../lvgl/Src/widgets/checkbox/: lv_checkbox.c
    ../lvgl/Src/widgets/colorwheel/: lv_colorwheel.c
    ../lvgl/Src/widgets/dropdown/: lv_dropdown.c
    ../lvgl/Src/widgets/img/: lv_img.c
    ../lvgl/Src/widgets/imgbtn/: lv_imgbtn.c
    ../lvgl/Src/widgets/keyboard/: lv_keyboard.c
    ../lvgl/Src/widgets/label/: lv_label.c
    ../lvgl/Src/widgets/led/: lv_led.c
    ../lvgl/Src/widgets/line/: lv_line.c
    ../lvgl/Src/widgets/list/: lv_list.c
    ../lvgl/Src/widgets/menu/: lv_menu.c
    ../lvgl/Src/widgets/meter/: lv_meter.c
    ../lvgl/Src/widgets/msgbox/: lv_msgbox.c
    ../lvgl/Src/widgets/objx_templ/: lv_objx_templ.c
    ../lvgl/Src/widgets/roller/: lv_roller.c
    ../lvgl/Src/widgets/slider/: lv_slider.c
    ../lvgl/Src/widgets/span/: lv_span.c
    ../lvgl/Src/widgets/spinbox/: lv_spinbox.c
    ../lvgl/Src/widgets/spinner/: lv_spinner.c
    ../lvgl/Src/widgets/switch/: lv_switch.c
    ../lvgl/Src/widgets/table/: lv_table.c
    ../lvgl/Src/widgets/tabview/: lv_tabview.c
    ../lvgl/Src/widgets/textarea/: lv_textarea.c
    ../lvgl/Src/widgets/tileview/: lv_tileview.c
    ../lvgl/Src/widgets/win/: lv_win.c
  group LVGL/fonts
    ../lvgl/Src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group LV
    ../lv/custom/: custom.c custom.h lv_conf_ext.h
    ../lv/generated/: events_init.c events_init.h gui_guider.c gui_guider.h setup_scr_screen.c widgets_init.c widgets_init.h
    ../lv/generated/guider_customer_fonts/: guider_customer_fonts.h
    ../lv/generated/images/: _laugh_alpha_172x173.c _scare_alpha_189x192.c
software components: CMSIS:CORE 5.5.0
